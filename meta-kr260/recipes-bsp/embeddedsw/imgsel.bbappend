# Ensure image selector uses the standard KR260 multiconfig naming
IMGSEL_MC_TARGET:k26-smk-kr-sdt = "k26-smk-kr-sdt-cortexa53-fsbl"
