PMU_FIRMWARE_DEPLOY_DIR:k26-smk-kr-sdt = "${TOPDIR}/tmp-k26-smk-kr-sdt-microblaze-pmu/deploy/images/${MACHINE}"
