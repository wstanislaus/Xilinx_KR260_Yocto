# Drop TPM2 stack as it isn't available for this build
KRIA_PACKAGES:remove = "packagegroup-security-tpm2"
